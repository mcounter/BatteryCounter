# IAR project BattRX.ewp, settings and files
configuration Release - Atmega328P (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnkm328ps.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: lnkm328ps.xcl main.cpp menu.xml
  group _Functions
    ./: CommonFunctions.cpp CRC8.cpp
  group _GLOBAL
    ./: GlobalSpace.h
  group _GLOBAL/ADC
    ./: GlobalADC.cpp
  group _GLOBAL/Counter
    ./: GlobalCounter.cpp
  group _GLOBAL/Definitions
    ./: GlobalDef_Parameters.h GlobalDef_PortMap.h GlobalDef_Timers.h GlobalDefinitions.h
  group _GLOBAL/DeviceManager
    ./: DeviceManager.cpp GlobalDeviceProfile.cpp
  group _GLOBAL/MultyThreading
    ./: MultyThreading.cpp
  group _GLOBAL/RTC
    ./: GlobalRTC.cpp
  group Communication/SPI
    ./: CommProtocol_SPI_Master.cpp
  group Communication/TWI
    ./: CommProtocol_TWI_Master.cpp
  group Drivers/Backlight
    ./: BacklightDriver.cpp
  group Drivers/Indicator
    ./: IndicatorDriver.cpp
  group Drivers/KeyBoard
    ./: KeyBoardDriver.cpp
  group Drivers/LCD
    ./: LCDDriver.cpp
  group Drivers/Memory
    ./: MemAT25Driver.cpp
  group Drivers/PhotoSensor
    ./: PhotoSensor.cpp
  group MainThread
    ./: MainThread.cpp
  group Timers
    ./: Timer0Handler.cpp Timer2Handler.cpp
  group UserInterface
    ./: UserInterface.cpp UserInterface_ScreenSaver.cpp UserInterface_Widget.cpp UserInterfaceLang.cpp UserInterfaceMenuBuilder.cpp
