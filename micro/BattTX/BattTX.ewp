# IAR project BattTX.ewp, settings and files
configuration Release - Atmega48PA (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m48pa ATmega48PA
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnkm48pas.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: lnkm48pas.xcl main.cpp menu.xml
  group _Functions
    ./: CommonFunctions.cpp
  group _GLOBAL
    ./: GlobalSpace.h
  group _GLOBAL/ADC
    ./: GlobalADC.cpp
  group _GLOBAL/Definitions
    ./: GlobalDef_Parameters.h GlobalDef_PortMap.h GlobalDef_Timers.h GlobalDefinitions.h
  group _GLOBAL/DeviceManager
    ./: DeviceManager.cpp GlobalDeviceProfile.cpp
  group _GLOBAL/MultyThreading
    ./: MultyThreading.cpp
  group Drivers/Indicator
    ./: IndicatorDriver.cpp
  group Drivers/KeyBoard
    ./: KeyBoardDriver.cpp
  group Timers
    ./: Timer0Handler.cpp
